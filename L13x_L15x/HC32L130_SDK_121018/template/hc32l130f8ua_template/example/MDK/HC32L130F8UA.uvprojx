# Keil uVision project HC32L130F8UA.uvprojx, settings and files
target HC32L130F8UA_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: HC32L130F8UA
  c flags: Optim=1 OneElfS=1
  c include: ..\..\common;..\source
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l130f8ua.s
    ../../common/: system_hc32l130f8ua.c
  group source
    ../source/: main.c
software components: CMSIS:CORE 4.1.0
