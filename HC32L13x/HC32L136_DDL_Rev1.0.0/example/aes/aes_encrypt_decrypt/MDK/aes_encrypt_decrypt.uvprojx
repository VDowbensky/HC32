# Keil uVision project aes_encrypt_decrypt.uvprojx, settings and files
target aes_encrypt_decrypt_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: aes_encrypt_decrypt
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l136.s
    ../../../../mcu/common/: system_hc32l136.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32l136.c sysctrl.c aes.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
