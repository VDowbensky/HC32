# IAR project HC32L176.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: D:\USB相关\USB_OF_L008\usb_hid_mouse\usb_mouse_v0.1\example\source; D:\USB相关\USB_OF_L008\usb_hid_mouse\usb_mouse_v0.1\usb_lib\device_class\hid\inc; D:\USB相关\USB_OF_L008\usb_hid_mouse\usb_mouse_v0.1\common; D:\USB相关\USB_OF_L008\usb_hid_mouse\usb_mouse_v0.1\hardware_driver\inc; D:\USB相关\USB_OF_L008\usb_hid_mouse\usb_mouse_v0.1\usb_lib\ctl_drv; D:\USB相关\USB_OF_L008\usb_hid_mouse\usb_mouse_v0.1\usb_lib\device_class\hid\inc; D:\USB相关\USB_OF_L008\usb_hid_mouse\usb_mouse_v0.1\usb_lib\device_core; D:\USB相关\USB_OF_L008\usb_hid_mouse\usb_mouse_v0.1\example\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HC32L176.srec
  ILINK.IlinkOutputFile: hc32l176.out
  ILINK.IlinkIcfFile: config\hc32l176.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  OBJCOPY.OOCOutputFile: hc32l176.srec
  group common
    ./: startup_hc32l176.s
    ../../common/: system_hc32l176.c
  group doc
    ../../: Readme.txt
  group hardware
    ../../hardware_driver/scr/: ddl.c gpio.c
  group source
    ../source/: main.c
  group usb_lib/usb_app
    ../source/: usb_bsp.c usbd_desc.c usbd_urs.c
  group usb_lib/usb_core
    ../../usb_lib/ctl_drv/: usb_core.c usb_dcd.c usb_dcd_int.c
  group usb_lib/usb_device
    ../../usb_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../usb_lib/device_class/hid/src/: usbd_hid_core.c
