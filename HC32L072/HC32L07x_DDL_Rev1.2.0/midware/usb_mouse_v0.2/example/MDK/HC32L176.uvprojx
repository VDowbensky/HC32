# Keil uVision project HC32L176.uvprojx, settings and files
target HC32L176_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: HC32L176 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\common;..\source;..\..\usb_lib\ctl_drv;..\..\usb_lib\device_core;..\source;..\source\other;..\..\hardware_driver\inc;..\..\fat;..\..\usb_lib\device_class\cdc\inc;..\..\usb_lib\device_class\hid\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l176.s
    ../../common/: system_hc32l176.c
  group usr_app
    ../source/: main.c
  group usb_device
    ../../usb_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../usb_lib/device_class/hid/src/: usbd_hid_core.c
  group usb_app
    ../source/: usbd_desc.c usbd_urs.c usb_bsp.c
  group usb_core
    ../../usb_lib/ctl_drv/: usb_core.c usb_dcd.c usb_dcd_int.c
  group hardware
    ../../hardware_driver/scr/: gpio.c ddl.c
  group doc
    ../../: Readme.txt
software components: CMSIS:CORE 5.1.2
