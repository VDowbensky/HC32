# IAR project HC32L176.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\source; D:\MCU\HC32L176\样例\i2s\i2s_i2c1_play_44k1\driver\inc; D:\MCU\HC32L176\样例\i2s\i2s_i2c1_play_44k1\wm8731\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32l176.srec
  ILINK.IlinkOutputFile: hc32l176.out
  ILINK.IlinkIcfFile: config\hc32l176.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  group common
    ./: startup_hc32l176.s
    ../../common/: system_hc32l176.c
  group driver
    ../../driver/src/: hc32l17x_i2s.c sysctrl.c
  group source
    ../source/: main.c
  group wm8731
    ../../wm8731/src/: data_sound_441_i2s.c wm8731.c
