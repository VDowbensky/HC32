# Keil uVision project HC32L176.uvprojx, settings and files
target HC32L176_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: HC32L176 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\common;..\source;..\..\driver\inc;..\..\wm8731\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l176.s
    ../../common/: system_hc32l176.c
  group source
    ../source/: main.c
  group driver
    ../../driver/src/: sysctrl.c hc32l17x_i2s.c
  group wm8731
    ../../wm8731/src/: wm8731.c data_sound_441_i2s.c
software components: CMSIS:CORE 4.1.0
