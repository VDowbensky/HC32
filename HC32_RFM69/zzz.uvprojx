# Keil uVision project zzz.uvprojx, settings and files
target hc32l130f8ua (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L130F8UA HDSC
  pack: HDSC.HC32L130.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: zzz +hex
  c flags: Optim=4 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=2
  c include: .\common;.\source;.\include;.\lib\inc;.\lib\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group source
    ./source/: main.c myeeprom.c mygpio.c myspi.c mytimers.c myuart.c RFM69.c testmode.c uart_commands.c
  group lib
    ./lib/src/: adc.c adt.c aes.c bgr.c bt.c crc.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c lcd.c lpm.c lpt.c lpuart.c lvd.c opa.c pca.c pcnt.c reset.c rng.c rtc.c spi.c sysctrl.c timer3.c trim.c uart.c vc.c wdt.c interrupts_hc32l136.c
  group startup
    ./common/: system_hc32l136.c startup_hc32l136.s
software components: CMSIS:CORE 5.6.0
